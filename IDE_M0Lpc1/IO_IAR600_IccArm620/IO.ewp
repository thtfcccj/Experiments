# IAR project IO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1227 NXP LPC1227
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SUPPORT_M0_LPC_V010
  ICCARM.CCIncludePath2: ..\..\..\Misc\LPC_M0; ..\..\source; ..\..\source\IOCtrl; ..\..\source\Native_M0Lpc1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Sys
    ../../../Misc/LPC_M0/: core_cm0.c core_cm0.h LPC12xx.h LPC12xxbit.h system_LPC12xx.c system_LPC12xx.h
    ../../source/IOCtrl/: IOCtrl.h
    ../../source/Native_M0Lpc1/: IOCtrl_M0Lpc1.h
    ../../source/: main_IO.c
