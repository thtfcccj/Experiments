# IAR project IO.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: SUPPORT_AVR1_V010
  ICCAVR.newCCIncludePaths: ..\..\Source\; ..\..\Source\IOCtrl; ..\..\Source\Native_Avr1
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group IOCtrl
    ../../source/IOCtrl/: IOCtrl.h
    ../../source/Native_Avr1/: IOCtrl_Avr1_V010.h
  group Sys
    ../../source/: main_IO.c
